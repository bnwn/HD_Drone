# Keil uVision project HD_Drone.uvproj, settings and files
target HD_Drone (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HD_Drone +hex
  c flags: Optim=1
  c include: .\Driver;.\Module;.\Library\Device\Panchip\PN020Series\Source\ARM;.\Library\Device\Panchip\PN020Series\Include;.\Library\StdDriver\inc
  link misc: --map --first='startup_PN020Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ./: main.c
  group CMSIS
    ./Library/Device/Panchip/PN020Series/Source/: system_PN020Series.c
    ./Library/Device/Panchip/PN020Series/Source/ARM/: startup_PN020Series.s
