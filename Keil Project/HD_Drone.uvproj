# Keil uVision project HD_Drone.uvproj, settings and files
target HD_Drone (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: HD_Drone +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Panchip\PN020Series\Include;..\Library\StdDriver\inc;..\Driver;..\AHRS;..\Algorithm\Algorithm_filter;..\Algorithm\Algorithm_pid;..\Algorithm\Algorithm_math;..\Algorithm\Algorithm_quaternion;..\Algorithm\Algorithm_sqLite;..\Control;..\Driver;..\Driver\bsp;..\Scheduler;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_PN020Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Driver
    ../Driver/: bmi160.c fbm320.c motor.c
  group User
    ../User/: common.c main.c
  group CMSIS
    ../Library/Device/Panchip/PN020Series/Source/: system_PN020Series.c
    ../Library/Device/Panchip/PN020Series/Source/ARM/: startup_PN020Series.s
  group Algorithm
    ../Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../Algorithm/Algorithm_math/: Algorithm_math.c mymath.c
    ../Algorithm/Algorithm_pid/: Algorithm_pid.c
    ../Algorithm/Algorithm_quaternion/: Algorithm_quaternion.c
    ../Algorithm/Algorithm_sqLite/: Algorithm_sqLite.c
  group Control
    ../Control/: attitude_control.c flight_mode_control.c position_control.c
  group Scheduler
    ../Scheduler/: scheduler.c
  group AHRS
    ../AHRS/: ahrs.c inertial_sensor.c
  group Bsp
    ../Driver/bsp/: bsp_i2c.c timer_delay.c uart_console.c
