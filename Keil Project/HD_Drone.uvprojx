# Keil uVision project HD_Drone.uvprojx, settings and files
target HD_Drone (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: HD_Drone
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Panchip\PN020Series\Include;..\Library\StdDriver\inc;..\Driver;..\AHRS;..\Algorithm\Algorithm_filter;..\Algorithm\Algorithm_pid;..\Algorithm\Algorithm_math;..\Algorithm\Algorithm_quaternion;..\Algorithm\Algorithm_sqLite;..\Control;..\Driver;..\Driver\bsp;..\Scheduler;..\User;..\RC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_PN020Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Driver
    ../Driver/: bmi160.c fbm320.c
  group User
    ../User/: common.c main.c
  group CMSIS
    ../Library/Device/Panchip/PN020Series/Source/: system_PN020Series.c
    ../Library/Device/Panchip/PN020Series/Source/ARM/: startup_PN020Series.s
  group Algorithm
    ../Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../Algorithm/Algorithm_math/: Algorithm_math.c
    ../Algorithm/Algorithm_pid/: Algorithm_pid.c
    ../Algorithm/Algorithm_quaternion/: Algorithm_quaternion.c
  group Control
    ../Control/: attitude_control.c flight_mode_control.c position_control.c motor_control.c
  group Scheduler
    ../Scheduler/: scheduler.c
  group AHRS
    ../AHRS/: ahrs.c inertial_sensor.c inertial_nav.c
  group Bsp
    ../Driver/bsp/: timer_delay.c bsp_i2c.c uart_console.c bsp_spi.c adc_det.c
    ../Driver/: motor.c
  group Library
    ../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group RC
    ../RC/: rc_channel.c rf.c
software components: CMSIS:CORE 4.3.0
